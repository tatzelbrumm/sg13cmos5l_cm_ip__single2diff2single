v {xschem version=3.4.8RC file_version=1.3}
G {}
V {}
E {}
S {}
C {ipin.sym} -120 0 0 0 {name=g0 lab=dig_in[23:0] }
C {ipin.sym} -120 20 0 0 {name=g1 lab=enable }
C {ipin.sym} -120 40 0 0 {name=g2 lab=clk }
C {ipin.sym} -120 60 0 0 {name=g3 lab=reset }
C {opin.sym} 120 0 0 0 {name=g4 lab=dig_out[11:0] }
C {iopin.sym} 120 20 0 0 {name=g5 lab=vss_1v2 }
C {iopin.sym} 120 40 0 0 {name=g6 lab=s7_an[0:1] }
C {iopin.sym} 120 60 0 0 {name=g7 lab=s7_an_0_esd }
C {iopin.sym} 120 80 0 0 {name=g8 lab=vbias }
C {iopin.sym} 120 100 0 0 {name=g9 lab=ibias0 }
C {iopin.sym} 120 120 0 0 {name=g10 lab=ibias1 }
C {iopin.sym} 120 140 0 0 {name=g11 lab=analog_bus3 }
C {iopin.sym} 120 160 0 0 {name=g12 lab=analog_bus2 }
C {iopin.sym} 120 180 0 0 {name=g13 lab=analog_bus1 }
C {iopin.sym} 120 200 0 0 {name=g14 lab=analog_bus0 }
C {iopin.sym} 120 220 0 0 {name=g15 lab=vdd_1v2 }
C {iopin.sym} 120 240 0 0 {name=g16 lab=vss_3v3 }
C {iopin.sym} 120 260 0 0 {name=g17 lab=vdd_3v3 }
