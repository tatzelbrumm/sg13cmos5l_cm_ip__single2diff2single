** sch_path: macros/OgueyAebischerBias/verification/cace/templates/reference_tb_dc.sch
**.subckt reference_tb_dc
x1 net2 vbp vbn net1 vbr 0 reference
VDD net2 0 CACE{vdd}
Voff net1 0 0
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.nodeset v(vbp)=200m
.control
save all
op
let Vbp_val = v(vbp)
let Vbn_val = v(vbn)
let Vbr_val = v(vbr)
let Ibias_val = v.x1.xbias.vi1#branch
echo $&Vbp_val $&Vbn_val $&Vbr_val $&Ibias_val > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
