** sch_path: macros/OgueyAebischerBias/verification/cace/templates/reference_tb_tran.sch
**.subckt reference_tb_tran
VDD net2 0 dc CACE{vdd} pwl(0 0 1u CACE{vdd})
Voff net1 0 0
x1 net2 vbp vbn net1 vbr 0 reference
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save all
tran CACE{tstep} CACE{tstop}
meas tran t_startup WHEN v(vbr)=100m RISE=1
meas tran Vbp_final find v(vbp) at=CACE{tstop}
meas tran Vbn_final find v(vbn) at=CACE{tstop}
meas tran Vbr_final find v(vbr) at=CACE{tstop}
echo $&t_startup $&Vbp_final $&Vbn_final $&Vbr_final > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
