** sch_path: macros/OgueyAebischerBias/verification/cace/templates/reference_tb_tran_disable.sch
**.subckt reference_tb_tran_disable
x1 net1 vbp vbn disable vbr 0 reference
VDD net1 0 CACE{vdd}
Vdis disable 0 dc 0 pulse(0 CACE{vdd} 200u 100n 100n 1 2)
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.nodeset v(vbp)=200m
.control
save all
tran CACE{tstep=100n} 400u
* supply current drawn = -i(vdd); vector is VDD#branch
meas tran iq_en_raw avg i(vdd) from=1.5e-4 to=1.95e-4
meas tran iq_dis_raw avg i(vdd) from=3.5e-4 to=3.95e-4
let Iq_enabled = -iq_en_raw
let Iq_disabled = -iq_dis_raw
* turn-off delay, referred to the 200us disable edge
meas tran t_dis_abs when v(vbr)=100m fall=1 td=2e-4
let t_disable = t_dis_abs - 2e-4
echo $&t_disable $&Iq_enabled $&Iq_disabled > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
