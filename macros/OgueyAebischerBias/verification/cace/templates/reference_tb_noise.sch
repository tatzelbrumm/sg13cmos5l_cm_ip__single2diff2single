** sch_path: macros/OgueyAebischerBias/verification/cace/templates/reference_tb_noise.sch
**.subckt reference_tb_noise
x1 net2 vbp vbn net1 vbr 0 reference
VDD net2 0 CACE{vdd}
Voff net1 0 0
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.nodeset v(vbp)=200m
*
* --- output-current sense network, see the note on the schematic ---
XMREP ndrep vbn 0 0 sg13_hv_nmos w=1u l=1u ng=1 m=1
VDS ndsup 0 CACE{vds_rep=1.0}
Vsense ndsup ndrep 0
HSENSE nsense 0 Vsense 1
*
.control
save all
op
noise v(nsense) VDD dec CACE{noise_pts=10} CACE{f_spot=1} CACE{fn_stop=100k}
setplot noise1
* sweep starts at f_spot, so index 0 IS the spot frequency
* echo the raw A/rtHz value -- CACE unconverts to the yaml's nA/rtHz for display
let Ibias_noise = onoise_spectrum[0]
* alternative: integrated RMS over the whole swept band
* setplot noise2
* let Ibias_noise = onoise_total
echo $&Ibias_noise > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
