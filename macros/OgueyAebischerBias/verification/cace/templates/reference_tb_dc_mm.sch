** sch_path: macros/OgueyAebischerBias/verification/cace/templates/reference_tb_dc_mm.sch
**.subckt reference_tb_dc_mm
x1 net2 vbp vbn net1 vbr 0 reference
VDD net2 0 CACE{vdd}
Voff net1 0 0
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.nodeset v(vbp)=200m
.control
save all
op
let I1 = v.x1.xbias.vi1#branch
let I2 = v.x1.xbias.vi4#branch
let I3 = v.x1.xbias.viaux#branch
let ibias_nom = CACE{ibias_nom=4.665e-8}
* echo as a raw fraction -- CACE unconverts to the yaml's '%' for display
let Ibias_accuracy = (I1 - ibias_nom) / ibias_nom
* PMOS mirror ratio M12:M13 = 1:4, so I2 should come out at 4*I1
let Leg_matching = (I2 / (4 * I1) - 1)
* to grade the 2x aux leg (M14) instead, use this line in its place:
* let Leg_matching = (I3 / (2 * I1) - 1)
echo $&Ibias_accuracy $&Leg_matching > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
