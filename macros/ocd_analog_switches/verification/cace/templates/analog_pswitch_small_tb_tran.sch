v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {CACE template: transient, enable toggling: polarity, delays, 10k||1p load, charge injection on a held 1 pF} 0 -600 0 0 0.6 0.6 {}
T {analog_pswitch_small: harness PMOS switch; sources and analysis are in the code blocks (generated by ../gen_cace.py)} 0 -560 0 0 0.3 0.3 {}
C {analog_pswitch_small.sym} 1400 0 0 0 {name=x1}
C {devices/lab_pin.sym} 1550 -50 0 1 {name=lp0 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 1550 -30 0 1 {name=lp1 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1550 -10 0 1 {name=lp2 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1250 60 0 0 {name=lp3 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 1550 10 0 1 {name=lp4 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1250 -50 0 0 {name=lp5 sig_type=std_logic lab=enable}
C {devices/lab_pin.sym} 1550 60 0 1 {name=lp6 sig_type=std_logic lab=out}
C {analog_pswitch_small.sym} 1900 0 0 0 {name=x2}
C {devices/lab_pin.sym} 2050 -50 0 1 {name=lp7 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 2050 -30 0 1 {name=lp8 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2050 -10 0 1 {name=lp9 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1750 60 0 0 {name=lp10 sig_type=std_logic lab=in2}
C {devices/lab_pin.sym} 2050 10 0 1 {name=lp11 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1750 -50 0 0 {name=lp12 sig_type=std_logic lab=enable}
C {devices/lab_pin.sym} 2050 60 0 1 {name=lp13 sig_type=std_logic lab=out}
C {devices/code_shown.sym} 0 -460 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOShv.lib mos_CACE\{corner_mos\}
.lib cornerMOSlv.lib mos_CACE\{corner_mos\}
.lib cornerDIO.lib dio_tt
"}
C {devices/code_shown.sym} 0 -340 0 0 {name=SOURCES only_toplevel=false
value="
Vdd dvdd 0 CACE\{dvdd=1.2\}
Vav avdd 0 CACE\{avdd=3.3\}
* enable (0.1 ns edges): 0 | on at 1 us | off at 3 us | on at 5 us | end 7 us
Ven enable 0 PWL(0 0 1u 0 1.0001u CACE\{dvdd=1.2\} 3u CACE\{dvdd=1.2\} 3.0001u 0 5u 0 5.0001u CACE\{dvdd=1.2\})
Vs out 0 CACE\{vsig=2.5\}
* x1: 10 kOhm || 1 pF load at in.  x2: held node in2 (1 pF only), starts at vsig
Rl in 0 10k
Cl in 0 1p
Ch in2 0 1p
.ic v(in2)=CACE\{vsig=2.5\}
"}
C {devices/code_shown.sym} 2600 -460 0 0 {name=NGSPICE simulator=ngspice only_toplevel=false
value="
* ---- sg13cmos5l_antennanp as in the PDK, but darea with tt = 0 (ngspice stalls on tt = 701 ns above 85 C in transients)
.subckt sg13cmos5l_antennanp A VDD VSS
XD1 VSS A dantenna_tt0 l=780n w=780n m=1
XD0 A VDD dpantenna l=1.34u w=1.05u m=1
.ends
.subckt dantenna_tt0 1 2
.params l=780n w=780n DEV_A=(l*w)/1p DEV_P=(l+w)/0.5u DEV_C=4
D1 1 2 darea_tt0 area=DEV_A
D2 1 2 dperim area=DEV_P
D3 1 2 dcorner area=DEV_C
.ends
.model darea_tt0 D (tnom=27 is=2.315E-019 n=1.009 ik=1.434E-007 rs=2.193E+005 cj0=9.371E-016 m=0.3036 vj=0.696 fc=0.5
+ bv=11.64 ibv=3.458E-007 tcv=0.001 nbv=48.9 isr=7.413E-019 xti=5.039 trs=0 trs2=0 tt=0)
* ---- the PDK standard cells FIRST: the DUT netlist below defines them again as empty subcircuits (ignored by ngspice)
.include sg13cmos5l_stdcell.spice
.include CACE\{DUT_path\}
.temp CACE\{temp\}
.options gmin=1e-15 abstol=1e-14 reltol=1e-4 method=gear SEED=CACE[CACE\{seed=12345\} + CACE\{iterations=0\}]
.option warn=1
.control
tran 0.1n 7u
let va = CACE\{avdd=3.3\}
let vs = CACE\{vsig=2.5\}
* gate of the pass PMOS (x1.net3) before each enable edge: off, on, off, on
meas tran g0 find v(x1.net3) at=0.99u
meas tran g1 find v(x1.net3) at=2.99u
meas tran g2 find v(x1.net3) at=4.99u
meas tran g3 find v(x1.net3) at=6.99u
let Verr_on = 0.5 * (g1 + g3 + abs(g1 - g3))
let Verr_off = va - 0.5 * (g0 + g2 - abs(g0 - g2))
* defaults (1 s) stay when a measurement finds no crossing
let td_on = 1
let td_off = 1
let t_on = 1
let t_off = 1
meas tran td_on trig v(enable) val=CACE[CACE\{dvdd=1.2\} / 2] td=4.5u rise=1 targ v(x1.net3) val=CACE[CACE\{avdd=3.3\} / 2] td=4.5u fall=1
meas tran td_off trig v(enable) val=CACE[CACE\{dvdd=1.2\} / 2] td=2.5u fall=1 targ v(x1.net3) val=CACE[CACE\{avdd=3.3\} / 2] td=2.5u rise=1
meas tran vl3 find v(in) at=6.99u
meas tran vl1 find v(in) at=2.99u
let V_load = vl3 / vs
let h3 = 0.5 * vl3
let h1 = 0.5 * vl1
meas tran t_on trig v(enable) val=CACE[CACE\{dvdd=1.2\} / 2] td=4.5u rise=1 targ v(in) val=$&h3 td=4.5u rise=1
meas tran t_off trig v(enable) val=CACE[CACE\{dvdd=1.2\} / 2] td=2.5u fall=1 targ v(in) val=$&h1 td=2.5u fall=1
meas tran hb find v(in2) at=2.99u
meas tran ha find v(in2) at=3.5u
let Q_inj = 1e-12 * (ha - hb)
echo $&Verr_on $&Verr_off $&td_on $&td_off $&t_on $&t_off $&V_load $&Q_inj > CACE\{simpath\}/CACE\{filename\}_CACE\{N\}.data
.endc
"}
