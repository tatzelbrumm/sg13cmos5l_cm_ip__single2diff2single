v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {CACE template: DC, bias-current leg: PMOS-mirror source -> switch -> 6u/6u hv NMOS diode, one off neighbour} 0 -600 0 0 0.6 0.6 {}
T {analog_pswitch_small: harness PMOS switch; sources and analysis are in the code blocks (generated by ../gen_cace.py)} 0 -560 0 0 0.3 0.3 {}
C {analog_pswitch_small.sym} 1400 0 0 0 {name=x1}
C {devices/lab_pin.sym} 1550 -50 0 1 {name=lp0 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 1550 -30 0 1 {name=lp1 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1550 -10 0 1 {name=lp2 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1250 60 0 0 {name=lp3 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 1550 10 0 1 {name=lp4 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1250 -50 0 0 {name=lp5 sig_type=std_logic lab=enable}
C {devices/lab_pin.sym} 1550 60 0 1 {name=lp6 sig_type=std_logic lab=o1}
C {analog_pswitch_small.sym} 1900 0 0 0 {name=x2}
C {devices/lab_pin.sym} 2050 -50 0 1 {name=lp7 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 2050 -30 0 1 {name=lp8 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2050 -10 0 1 {name=lp9 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1750 60 0 0 {name=lp10 sig_type=std_logic lab=in2}
C {devices/lab_pin.sym} 2050 10 0 1 {name=lp11 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1750 -50 0 0 {name=lp12 sig_type=std_logic lab=en2}
C {devices/lab_pin.sym} 2050 60 0 1 {name=lp13 sig_type=std_logic lab=o2}
C {devices/code_shown.sym} 0 -460 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOShv.lib mos_CACE\{corner_mos\}
.lib cornerMOSlv.lib mos_CACE\{corner_mos\}
.lib cornerDIO.lib dio_tt
"}
C {devices/code_shown.sym} 0 -340 0 0 {name=SOURCES only_toplevel=false
value="
Vdd dvdd 0 CACE\{dvdd=1.2\}
Vav avdd 0 CACE\{avdd=3.3\}
Ven enable 0 CACE\{dvdd=1.2\}
Ven2 en2 0 0
* ---- harness iDAC stand-in: sourced current from a 1:1 hv PMOS mirror on avdd (the harness iDAC is a cascoded hv PMOS
*      source on vdd3v3); out = the shared iDAC node (idac1_source / idac2_source of chipalooza_frame)
Iref g 0 CACE\{ibias=5e-6\}
XPd g g avdd avdd sg13_hv_pmos w=10u l=2u ng=1 m=4
XPm src g avdd avdd sg13_hv_pmos w=10u l=2u ng=1 m=4
Vmo src out 0
* x1 = the switch under test (on), x2 = one off neighbour on the same node (the harness has 18 per iDAC)
Vm1 out o1 0
Vm2 out o2 0
* load: the NMOS input diode of a bias tree (hv 6u/6u); the neighbour's in sits on an unbiased diode of the same size
Vmi in d 0
XN d d 0 0 sg13_hv_nmos w=6u l=6u ng=1 m=1
Vmn in2 d2 0
XN2 d2 d2 0 0 sg13_hv_nmos w=6u l=6u ng=1 m=1
.nodeset v(x1.x5.net1)=0 v(x1.x5.s1_n)=CACE\{avdd=3.3\} v(x2.x5.net1)=CACE\{avdd=3.3\} v(x2.x5.s1_n)=0
"}
C {devices/code_shown.sym} 2600 -460 0 0 {name=NGSPICE simulator=ngspice only_toplevel=false
value="
* ---- the PDK standard cells FIRST: the DUT netlist below defines them again as empty subcircuits (ignored by ngspice)
.include sg13cmos5l_stdcell.spice
.include CACE\{DUT_path\}
.temp CACE\{temp\}
.options gmin=1e-15 abstol=1e-15 reltol=1e-4
.option warn=1
.control
op
let i1 = i(Vm1)
let inb = i(Vm2)
let iin = i(Vmi)
let V_in = v(in)
let V_out = v(out)
let V_drop = v(out) - v(in)
let V_head = CACE\{avdd=3.3\} - v(out)
let I_in = iin
* errors in percent: (delivered - taken) / taken; I_err18 with 18 off neighbours that also draw from the iDAC node
let I_err = 100 * (iin - i1) / i1
let I_nb = inb
let I_err18 = 100 * (iin - i1 - 18 * inb) / (i1 + 18 * inb)
let Vg = v(x1.net3)
echo $&V_in $&V_out $&V_drop $&V_head $&I_in $&I_err $&I_nb $&I_err18 $&Vg > CACE\{simpath\}/CACE\{filename\}_CACE\{N\}.data
.endc
"}
