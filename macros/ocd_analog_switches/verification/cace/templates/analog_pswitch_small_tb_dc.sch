v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {CACE template: DC, switch between two voltage sources (on-resistance, leakage, supply currents)} 0 -600 0 0 0.6 0.6 {}
T {analog_pswitch_small: harness PMOS switch; sources and analysis are in the code blocks (generated by ../gen_cace.py)} 0 -560 0 0 0.3 0.3 {}
C {analog_pswitch_small.sym} 1400 0 0 0 {name=x1}
C {devices/lab_pin.sym} 1550 -50 0 1 {name=lp0 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 1550 -30 0 1 {name=lp1 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1550 -10 0 1 {name=lp2 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1250 60 0 0 {name=lp3 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 1550 10 0 1 {name=lp4 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1250 -50 0 0 {name=lp5 sig_type=std_logic lab=enable}
C {devices/lab_pin.sym} 1550 60 0 1 {name=lp6 sig_type=std_logic lab=out}
C {devices/code_shown.sym} 0 -460 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOShv.lib mos_CACE\{corner_mos\}
.lib cornerMOSlv.lib mos_CACE\{corner_mos\}
.lib cornerDIO.lib dio_tt
"}
C {devices/code_shown.sym} 0 -340 0 0 {name=SOURCES only_toplevel=false
value="
* case: 0 on (enable = dvdd) | 1 off (enable = 0) | 2 dvdd = 0, enable = 0, latch preset ON | 3 same, preset OFF
.param c=CACE\{case=0\}
.param vdd_d='(c >= 2) ? 0 : CACE\{dvdd=1.2\}'
.param ven='(c == 0) ? CACE\{dvdd=1.2\} : 0'
* vin < 0: in follows out - 10 mV (on-resistance); else in = vin.  out is swept vout - 10 mV .. vout in the analysis.
.param vo=CACE\{vout=1.0\}
.param vi='(CACE\{vin=-1\} < 0) ? vo - 0.01 : CACE\{vin=-1\}'
Vdd dvdd 0 \{vdd_d\}
Vav avdd 0 CACE\{avdd=3.3\}
Ven enable 0 \{ven\}
Vout out 0 \{vo\}
Vin in 0 \{vi\}
* level-shifter latch preset (x1.x5 = sw_lvl_shift; ON: net1 low, S1_N high).  Driven cases: the input decides
* (the transient groups show that it can flip the latch); cases 2 / 3: the DC state that the preset falls into.
.nodeset v(x1.x5.net1)=CACE[CACE\{avdd=3.3\} * (CACE\{case=0\} % 2)] v(x1.x5.s1_n)=CACE[CACE\{avdd=3.3\} * (1 - CACE\{case=0\} % 2)]
"}
C {devices/code_shown.sym} 2600 -460 0 0 {name=NGSPICE simulator=ngspice only_toplevel=false
value="
* ---- the PDK standard cells FIRST: the DUT netlist below defines them again as empty subcircuits (ignored by ngspice)
.include sg13cmos5l_stdcell.spice
.include CACE\{DUT_path\}
.temp CACE\{temp\}
.options gmin=1e-15 abstol=1e-15 reltol=1e-4
.option warn=1
.control
dc Vout CACE[CACE\{vout=1.0\} - 0.01] CACE[CACE\{vout=1.0\} + 0.0001] 0.01
let iout = -i(Vout)
let iin = -i(Vin)
let idd = -i(Vdd)
let iav = -i(Vav)
let ien = -i(Ven)
let vg = v(x1.net3)
* R_sw = 10 mV / change of the out current (cancels the junction leakage of out to the n-well)
let R_sw = 0.01 / (abs(iout[1] - iout[0]) + 1e-24)
let I_out = iout[1]
let I_in = iin[1]
let I_dvdd = idd[1]
let I_avdd = iav[1]
let I_en = ien[1]
let Vg = vg[1]
echo $&R_sw $&I_out $&I_in $&I_dvdd $&I_avdd $&I_en $&Vg > CACE\{simpath\}/CACE\{filename\}_CACE\{N\}.data
.endc
"}
