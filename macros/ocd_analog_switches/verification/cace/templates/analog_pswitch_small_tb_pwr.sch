v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {CACE template: transient, dvdd lost / avdd up without dvdd: state of the switch over 100 ms} 0 -600 0 0 0.6 0.6 {}
T {analog_pswitch_small: harness PMOS switch; sources and analysis are in the code blocks (generated by ../gen_cace.py)} 0 -560 0 0 0.3 0.3 {}
C {analog_pswitch_small.sym} 1400 0 0 0 {name=x1}
C {devices/lab_pin.sym} 1550 -50 0 1 {name=lp0 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} 1550 -30 0 1 {name=lp1 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1550 -10 0 1 {name=lp2 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1250 60 0 0 {name=lp3 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 1550 10 0 1 {name=lp4 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1250 -50 0 0 {name=lp5 sig_type=std_logic lab=enable}
C {devices/lab_pin.sym} 1550 60 0 1 {name=lp6 sig_type=std_logic lab=out}
C {devices/code_shown.sym} 0 -460 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOShv.lib mos_CACE\{corner_mos\}
.lib cornerMOSlv.lib mos_CACE\{corner_mos\}
.lib cornerDIO.lib dio_tt
"}
C {devices/code_shown.sym} 0 -340 0 0 {name=SOURCES only_toplevel=false
value="
* scen 1: dvdd lost at 10 us (1 us ramp) with the switch on, enable follows dvdd; dvdd and enable back at 100 ms
* scen 2: same with the switch off | scen 3: avdd ramps up 10 .. 20 us with dvdd = 0, enable = 0; dvdd up at 100 ms
.param sc=CACE\{scen=1\} vl=CACE\{dvdd=1.2\} va=CACE\{avdd=3.3\}
.param vd0='(sc == 3) ? 0 : vl'
.param en0='(sc == 1) ? vl : 0'
.param va0='(sc == 3) ? 0 : va'
.param gx='(sc == 1) ? 0 : va'
Vdd dvdd 0 PWL(0 \{vd0\} 10u \{vd0\} 11u 0 100m 0 100.001m \{vl\})
Ven enable 0 PWL(0 \{en0\} 10u \{en0\} 11u 0 100m 0 100.001m \{en0\})
Vav avdd 0 PWL(0 \{va0\} 10u \{va0\} 20u \{va\})
* expected gate voltage after dvdd is back (0 on, avdd off)
Vx gx 0 \{gx\}
Vs out 0 2.0
Rl in 0 10k
"}
C {devices/code_shown.sym} 2600 -460 0 0 {name=NGSPICE simulator=ngspice only_toplevel=false
value="
* ---- sg13cmos5l_antennanp as in the PDK, but darea with tt = 0 (ngspice stalls on tt = 701 ns above 85 C in transients)
.subckt sg13cmos5l_antennanp A VDD VSS
XD1 VSS A dantenna_tt0 l=780n w=780n m=1
XD0 A VDD dpantenna l=1.34u w=1.05u m=1
.ends
.subckt dantenna_tt0 1 2
.params l=780n w=780n DEV_A=(l*w)/1p DEV_P=(l+w)/0.5u DEV_C=4
D1 1 2 darea_tt0 area=DEV_A
D2 1 2 dperim area=DEV_P
D3 1 2 dcorner area=DEV_C
.ends
.model darea_tt0 D (tnom=27 is=2.315E-019 n=1.009 ik=1.434E-007 rs=2.193E+005 cj0=9.371E-016 m=0.3036 vj=0.696 fc=0.5
+ bv=11.64 ibv=3.458E-007 tcv=0.001 nbv=48.9 isr=7.413E-019 xti=5.039 trs=0 trs2=0 tt=0)
* ---- the PDK standard cells FIRST: the DUT netlist below defines them again as empty subcircuits (ignored by ngspice)
.include sg13cmos5l_stdcell.spice
.include CACE\{DUT_path\}
.temp CACE\{temp\}
.options gmin=1e-15 abstol=1e-14 reltol=1e-4 method=gear SEED=CACE[CACE\{seed=12345\} + CACE\{iterations=0\}]
.option warn=1
.control
tran 10u 100.05m 0 0.5m
let va = CACE\{avdd=3.3\}
* S = gate / avdd: 1 = off, 0 = on
meas tran g50u find v(x1.net3) at=50u
meas tran g1m find v(x1.net3) at=1m
meas tran g10m find v(x1.net3) at=10m
meas tran g100m find v(x1.net3) at=99.9m
meas tran gend find v(x1.net3) at=100.04m
meas tran gexp find v(gx) at=100.04m
meas tran iav find i(Vav) at=99.9m
let S_50u = g50u / va
let S_1m = g1m / va
let S_10m = g10m / va
let S_100m = g100m / va
let I_avdd = -iav
let Verr_end = abs(gend - gexp)
echo $&S_50u $&S_1m $&S_10m $&S_100m $&I_avdd $&Verr_end > CACE\{simpath\}/CACE\{filename\}_CACE\{N\}.data
.endc
"}
