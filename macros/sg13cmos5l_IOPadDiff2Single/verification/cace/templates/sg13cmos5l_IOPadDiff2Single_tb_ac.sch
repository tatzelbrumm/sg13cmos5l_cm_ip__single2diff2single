** sch_path: macros/sg13cmos5l_IOPadDiff2Single/verification/cace/templates/sg13cmos5l_IOPadDiff2Single_tb_ac.sch
**.subckt sg13cmos5l_IOPadDiff2Single_tb_ac
x1 iovdd 0 vcore 0 pad vinp vinn vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadDiff2Single
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
* IHP IO library (DCNDiode, DCPDiode); on the sourcepath of the PDK .spiceinit
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = ring 3.3 V (front end, bias, output stage), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- differential input around vicm: vinp - vinn = v(dp)
Vref vref 0 CACE{vref=1.65}
Vic vic 0 dc CACE{vicm=1.65} ac 0
Vd dp 0 dc 0 ac 1
Ep vinp vic dp 0 0.5
En vinn vic dp 0 -0.5
* ---- load
RL pad vterm CACE{rload=1000}
Vterm vterm 0 CACE{vterm=1.65}
CL pad 0 CACE{cload=1e-10}
Itest 0 pad dc 0 ac 0




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(pad)
ac dec 50 1 1G
let adb = vdb(pad)
meas ac Acl find adb at=1k
let adn = adb - Acl
let f3db = 0
meas ac f3db when adn=-3 fall=1
meas ac Apk max adn
set s_acl = $&Acl
set s_f3db = $&f3db
set s_pk = $&Apk
alter @vd[acmag]=0
alter @vio[acmag]=1
ac dec 50 1 1G
let psr = -vdb(pad)
meas ac PSRR_1k find psr at=1k
meas ac PSRR_100k find psr at=100k
set s_p1 = $&PSRR_1k
set s_p2 = $&PSRR_100k
alter @vio[acmag]=0
alter @vic[acmag]=1
ac dec 50 1 1G
let cmdb = vdb(pad)
meas ac Acm find cmdb at=1k
set s_acm = $&Acm
alter @vic[acmag]=0
alter @itest[acmag]=1
ac dec 50 1 1G
let zo = mag(v(pad))
meas ac Zout_1k find zo at=1k
meas ac Zout_1M find zo at=1meg
let Acl_dB = $s_acl
let f3dB = $s_f3db
let Peak_dB = $s_pk
let PSRR_1k = $s_p1
let PSRR_100k = $s_p2
let CMRR_1k = $s_acl - $s_acm
echo $&Acl_dB $&f3dB $&Peak_dB $&PSRR_1k $&PSRR_100k $&CMRR_1k $&Zout_1k $&Zout_1M > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
