** sch_path: macros/sg13cmos5l_IOPadDiff2Single/verification/cace/templates/d2s_mpdda_pd_sel_tb_loop.sch
**.subckt d2s_mpdda_pd_sel_tb_loop
x1 vdd 0 vdd 0 vinp vinn vref vout fb ibias vdd 0 s0 s1 d2s_mpdda_pd_sel
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}



* all rails on one supply (the pad's iovdd / iovss); en_3v3 tied to vdd, en_3v3_b to 0
Vdd vdd 0 CACE{vdd}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vdd}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vdd}]
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
Vref vref 0 CACE{vref=1.65}
Vic vic 0 CACE{vicm=1.65}
Ep vinp vic 0 0 0.5
En vinn vic 0 0 -0.5
* loop broken at vfb: DC through Lb, AC injected through Cb
Lb vout fb 1G
Cb fb inj 1
Vinj inj 0 dc 0 ac 1
RL vout vterm CACE{rload=1000}
Vterm vterm 0 CACE{vterm=1.65}
CL vout 0 CACE{cload=1e-10}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.option warn=1
.control
save v(vout) v(fb)
ac dec 50 1 1G
let T = -v(vout)/v(fb)
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac T0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let PM = 180 + phc
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
let GM = -gmdb
echo $&T0 $&fc $&PM $&GM > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
