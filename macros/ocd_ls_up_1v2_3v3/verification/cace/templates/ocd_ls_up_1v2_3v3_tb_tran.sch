** sch_path: macros/ocd_ls_up_1v2_3v3/verification/cace/templates/ocd_ls_up_1v2_3v3_tb_tran.sch
* macros/ocd_ls_up_1v2_3v3/schematic/xschem/ocd_ls_up_1v2_3v3.sym:
* Copyright 2023 IHP PDK Authors, Apache License 2.0 (https://www.apache.org/licenses/LICENSE-2.0)
**.subckt ocd_ls_up_1v2_3v3_tb_tran
x1 GND vddl vddh out in ocd_ls_up_1v2_3v3
VL vddl GND dc CACE{vddl}
VH vddh GND dc CACE{vddh}
VIN in GND PULSE(0 CACE{vddl} 10n CACE{tr} CACE{tr} 60n 1)
CL out GND CACE{cload} m=1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options gmin=1e-15 abstol=1e-15 reltol=1e-4
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control
tran 20p 120n
* ---- time base (s): rising edge starts at t0r, falling edge at t0f; windows end tsettle after the input is done
let tr = CACE{tr}
let tsettle = 10e-9
let t0r = 10e-9
let t1r = t0r + tr + tsettle
let t0f = t0r + tr + 60e-9
let t1f = t0f + tr + tsettle
let b0r = t0r - 4e-9
let b1r = t0r - 0.5e-9
let b0f = t0f - 4e-9
let b1f = t0f - 0.5e-9
let vmid_in = CACE{vddl} / 2
let vmid_out = CACE{vddh} / 2
* ---- delays, 50 % input to 50 % output
meas tran m_td_r trig v(in) val=$&vmid_in rise=1 targ v(out) val=$&vmid_out rise=1
meas tran m_td_f trig v(in) val=$&vmid_in fall=1 targ v(out) val=$&vmid_out fall=1
* ---- output levels, settled (just before the next edge)
meas tran m_Voh avg v(out) from=$&b0f to=$&b1f
meas tran m_Vol avg v(out) from=$&b0r to=$&b1r
let td_r = m_td_r
let td_f = m_td_f
let Voh = m_Voh
let Vol = m_Vol
* ---- quiescent, peak and charge per source
let ab_l = abs(vl#branch)
meas tran iq_l_lo avg i(VL) from=$&b0r to=$&b1r
meas tran iq_l_hi avg i(VL) from=$&b0f to=$&b1f
meas tran q_l_r integ i(VL) from=$&t0r to=$&t1r
meas tran ib_l_r avg i(VL) from=$&b0r to=$&b1r
meas tran pk_l_r max ab_l from=$&t0r to=$&t1r
meas tran q_l_f integ i(VL) from=$&t0f to=$&t1f
meas tran ib_l_f avg i(VL) from=$&b0f to=$&b1f
meas tran pk_l_f max ab_l from=$&t0f to=$&t1f
let ab_h = abs(vh#branch)
meas tran iq_h_lo avg i(VH) from=$&b0r to=$&b1r
meas tran iq_h_hi avg i(VH) from=$&b0f to=$&b1f
meas tran q_h_r integ i(VH) from=$&t0r to=$&t1r
meas tran ib_h_r avg i(VH) from=$&b0r to=$&b1r
meas tran pk_h_r max ab_h from=$&t0r to=$&t1r
meas tran q_h_f integ i(VH) from=$&t0f to=$&t1f
meas tran ib_h_f avg i(VH) from=$&b0f to=$&b1f
meas tran pk_h_f max ab_h from=$&t0f to=$&t1f
let ab_i = abs(vin#branch)
meas tran iq_i_lo avg i(VIN) from=$&b0r to=$&b1r
meas tran iq_i_hi avg i(VIN) from=$&b0f to=$&b1f
meas tran q_i_r integ i(VIN) from=$&t0r to=$&t1r
meas tran ib_i_r avg i(VIN) from=$&b0r to=$&b1r
meas tran pk_i_r max ab_i from=$&t0r to=$&t1r
meas tran q_i_f integ i(VIN) from=$&t0f to=$&t1f
meas tran ib_i_f avg i(VIN) from=$&b0f to=$&b1f
meas tran pk_i_f max ab_i from=$&t0f to=$&t1f
* ---- results in SI units (s, V, A, C, J); the yaml units (ns, pA, fC, uA, fW*s) are display units.  Delivered by the source = positive.
let Iq_vddl_inlo = -iq_l_lo
let Iq_vddl_inhi = -iq_l_hi
let Iq_vddh_inlo = -iq_h_lo
let Iq_vddh_inhi = -iq_h_hi
let Iq_in_inlo = abs(iq_i_lo)
let Iq_in_inhi = abs(iq_i_hi)
let Q_vddl_r = -(q_l_r - ib_l_r * (t1r - t0r))
let Q_vddl_f = -(q_l_f - ib_l_f * (t1f - t0f))
let Q_vddh_r = -(q_h_r - ib_h_r * (t1r - t0r))
let Q_vddh_f = -(q_h_f - ib_h_f * (t1f - t0f))
let Q_in_r = abs(q_i_r - ib_i_r * (t1r - t0r))
let Q_in_f = abs(q_i_f - ib_i_f * (t1f - t0f))
let Ipk_vddl_r = pk_l_r
let Ipk_vddl_f = pk_l_f
let Ipk_vddh_r = pk_h_r
let Ipk_vddh_f = pk_h_f
let Ipk_in_r = pk_i_r
let Ipk_in_f = pk_i_f
let E_cycle = (Q_vddl_r + Q_vddl_f) * CACE{vddl} + (Q_vddh_r + Q_vddh_f) * CACE{vddh}
echo $&td_r $&td_f $&Voh $&Vol $&Iq_vddl_inlo $&Iq_vddl_inhi $&Iq_vddh_inlo $&Iq_vddh_inhi $&Iq_in_inlo $&Iq_in_inhi $&Q_vddl_r $&Q_vddl_f $&Q_vddh_r $&Q_vddh_f $&Q_in_r $&Q_in_f $&Ipk_vddl_r $&Ipk_vddl_f $&Ipk_vddh_r $&Ipk_vddh_f $&Ipk_in_r $&Ipk_in_f $&E_cycle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.include $::env(PDK_ROOT)/$::env(PDK)/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

**** end user architecture code
**.ends

* expanding   symbol:  ocd_ls_up_1v2_3v3.sym # of pins=5
** sym_path: macros/ocd_ls_up_1v2_3v3/schematic/xschem/ocd_ls_up_1v2_3v3.sym
** sch_path: macros/ocd_ls_up_1v2_3v3/schematic/xschem/ocd_ls_up_1v2_3v3.sch
.subckt ocd_ls_up_1v2_3v3 vss vddl vddh out in
*.iopin vss
*.iopin vddl
*.iopin vddh
*.opin out
*.ipin in
x2 net1 in vddl vss sg13cmos5l_inv_4
x3 net2 net1 vddl vss sg13cmos5l_inv_4
x1 net2 net1 out net3 vddh vss sw_lvl_shift
.ends


* expanding   symbol:  sw_lvl_shift.sym # of pins=4
** sym_path: macros/ocd_analog_switches/schematic/xschem/sw_lvl_shift.sym
** sch_path: macros/ocd_analog_switches/schematic/xschem/sw_lvl_shift.sch
.subckt sw_lvl_shift in_p in_n out outn avdd avss
*.ipin in_n
*.ipin in_p
*.opin out
*.opin outn
XM1 net1 in_p avss avss sg13_hv_nmos w=2u l=0.5u ng=1 m=1 mm_ok=1
XM2 net1 S1_N avdd avdd sg13_hv_pmos w=0.5u l=0.5u ng=1 m=1 mm_ok=1
XM3 S1_N in_n avss avss sg13_hv_nmos w=2u l=0.5u ng=1 m=1 mm_ok=1
XM4 S1_N net1 avdd avdd sg13_hv_pmos w=0.5u l=0.5u ng=1 m=1 mm_ok=1
XM5 outn S1_N avdd avdd sg13_hv_pmos w=2u l=0.5u ng=1 m=2 mm_ok=1
XM6 outn S1_N avss avss sg13_hv_nmos w=1u l=0.5u ng=1 m=2 mm_ok=1
XM7 out outn avdd avdd sg13_hv_pmos w=2u l=0.5u ng=1 m=2 mm_ok=1
XM8 out outn avss avss sg13_hv_nmos w=1u l=0.5u ng=1 m=2 mm_ok=1
.ends

.GLOBAL GND
.end
