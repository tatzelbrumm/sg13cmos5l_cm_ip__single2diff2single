v {xschem version=3.4.8RC file_version=1.3}
G {}
V {}
E {}
S {}
C {ipin.sym} -120 0 0 0 {name=g0 lab=vcm }
C {ipin.sym} -120 20 0 0 {name=g1 lab=in }
C {opin.sym} 120 0 0 0 {name=g2 lab=outp }
C {opin.sym} 120 20 0 0 {name=g3 lab=outn }
C {iopin.sym} 120 40 0 0 {name=g4 lab=vdd }
C {iopin.sym} 120 60 0 0 {name=g5 lab=vss }
