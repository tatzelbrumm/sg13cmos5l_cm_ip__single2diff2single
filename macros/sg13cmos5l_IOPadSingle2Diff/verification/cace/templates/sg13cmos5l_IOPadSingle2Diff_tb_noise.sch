** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_noise.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_noise
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = IO ring 3.3 V (buffer, bias, control), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- references (gates only) and the input: pad source = vref + u, through rsrc
Vref vref 0 dc CACE{vref=1.2} ac 0
Vcm vcm 0 CACE{vcm=1.2}
Vu u 0 dc 0 ac 1
Ein vsrc vref u 0 1
Rsrc vsrc pad CACE{rsrc=50}
* ---- load per output (gates of the next stage, routing), on top of the buffer's built-in CLP / CLN
Cp outp 0 CACE{cload=0.5e-12}
Cn outn 0 CACE{cload=0.5e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents sparse method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1
.control
noise v(outp,outn) Vu dec 20 10 10meg
setplot noise2
let Vn_out = onoise_total
set s_vn = $&Vn_out
noise v(outp,outn) Vu lin 1 1k 1k
let En_1k = inoise_spectrum[0]
set s_e1 = $&En_1k
noise v(outp,outn) Vu lin 1 100k 100k
let En_100k = inoise_spectrum[0]
let En_1k = $s_e1
let Vn_out = $s_vn
echo $&En_1k $&En_100k $&Vn_out > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
