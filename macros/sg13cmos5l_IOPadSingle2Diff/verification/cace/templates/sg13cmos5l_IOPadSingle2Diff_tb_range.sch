** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_range.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_range
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = IO ring 3.3 V (buffer, bias, control), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- references (gates only) and the input: pad source = vref + u, through rsrc
Vref vref 0 dc CACE{vref=1.2} ac 0
Vcm vcm 0 CACE{vcm=1.2}
Vu u 0 dc 0
Ein vsrc vref u 0 1
Rsrc vsrc pad CACE{rsrc=50}
* ---- load per output (gates of the next stage, routing), on top of the buffer's built-in CLP / CLN
Cp outp 0 CACE{cload=0.5e-12}
Cn outn 0 CACE{cload=0.5e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1
.control
save v(pad) v(outp) v(outn) v(u)
dc Vu CACE[-CACE{vref=1.2}] CACE[CACE{vdd} - CACE{vref=1.2}] 0.01
let vd = v(outp) - v(outn)
meas dc vdp find vd at=0.1
meas dc vdm find vd at=-0.1
meas dc vd0 find vd at=0
let Gain = (vdp - vdm)/0.2
let err = abs(vd - vd0 - Gain*v(u))/Gain
* defaults: the ends of the sweep, if the error stays below 1 mV there
let vlo = 0
let vhi = CACE{vdd}
* the contiguous range around u = 0: last crossing below u = 0, first crossing above it
meas dc ulo when err=1m fall=last to=0
meas dc uhi when err=1m rise=1 from=0
let vlo = ulo + CACE{vref=1.2}
let vhi = uhi + CACE{vref=1.2}
let Vin_min = vlo
let Vin_max = vhi
echo $&Vin_min $&Vin_max > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
