** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/s2d_mpdda_pd_sel_tb_loop.sch
**.subckt s2d_mpdda_pd_sel_tb_loop
x1 vdd 0 vref vref vcm voutp voutn fbp fbn ibias vdd s0 s1 0 s2d_mpdda_pd_sel
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}



* all rails on one supply (the pad's iovdd / iovss)
Vdd vdd 0 CACE{vdd}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vdd}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vdd}]
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
Vref vref 0 CACE{vref=1.2}
Vcm vcm 0 CACE{vcm=1.2}
* load per output
CLp voutp 0 CACE{cload=0.5e-12}
CLn voutn 0 CACE{cload=0.5e-12}
* loop broken at vfbp / vfbn
Lbp voutp fbp 1G
Lbn voutn fbn 1G
Cbp fbp injp 1
Cbn fbn injn 1
Vinjp injp 0 dc 0 ac 1
Vinjn injn 0 dc 0 ac 1 180




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1
.control
save v(voutp) v(voutn) v(fbp) v(fbn)
ac dec 50 10 1G
let T = -(v(voutp) - v(voutn))/(v(fbp) - v(fbn))
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac t0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
set s_T0dm = $&t0
set s_fcdm = $&fc
set s_PMdm = $&phc
set s_GMdm = $&gmdb
alter @Vinjn[acphase] = 0
ac dec 50 10 1G
let T = -(v(voutp) + v(voutn))/(v(fbp) + v(fbn))
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac t0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
let T0dm = $s_T0dm
let fcdm = $s_fcdm
let PMdm = 180 + $s_PMdm
let GMdm = 0 - $s_GMdm
let T0cm = t0
let fccm = fc
let PMcm = 180 + phc
let GMcm = 0 - gmdb
echo $&T0dm $&fcdm $&PMdm $&GMdm $&T0cm $&fccm $&PMcm $&GMcm > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
