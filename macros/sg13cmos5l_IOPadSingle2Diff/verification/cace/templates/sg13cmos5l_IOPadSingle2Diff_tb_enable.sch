** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_enable.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_enable
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = IO ring 3.3 V (buffer, bias, control), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 pwl(0 0 1u 0 1.001u CACE{vddl=1.2})
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- references (gates only) and the input: pad source = vref + u, through rsrc
Vref vref 0 dc CACE{vref=1.2} ac 0
Vcm vcm 0 CACE{vcm=1.2}
Vu u 0 dc CACE{u=0.25}
Ein vsrc vref u 0 1
Rsrc vsrc pad CACE{rsrc=50}
* ---- load per output (gates of the next stage, routing), on top of the buffer's built-in CLP / CLN
Cp outp 0 CACE{cload=0.5e-12}
Cn outn 0 CACE{cload=0.5e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-12 gmin=1e-12 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1
.control
save v(outp) v(outn) v(vcm) i(vio)
tran 5n CACE{tstop=10u}
let vd = v(outp) - v(outn)
let vc = (v(outp) + v(outn))/2 - v(vcm)
meas tran vd_end find vd at=CACE{tstop=10u}
let ee = abs(vd - vd_end)
let t1 = 1u
meas tran t1 when ee=1m cross=last from=1u to=CACE{tstop=10u}
let t_on = t1 - 1u
meas tran Vc_max max vc from=1u to=CACE{tstop=10u}
meas tran Vc_min min vc from=1u to=CACE{tstop=10u}
let iio = -i(vio)
meas tran Iio_end find iio at=CACE{tstop=10u}
echo $&t_on $&Vc_max $&Vc_min $&vd_end $&Iio_end > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
