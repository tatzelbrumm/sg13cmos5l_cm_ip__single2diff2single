** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_ac.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_ac
x1 iovdd gio vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = IO ring 3.3 V (buffer, bias, control), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- references (gates only) and the input: pad source = vref + u, through rsrc
Vref vref 0 dc CACE{vref=1.2} ac 0
Vcm vcm 0 CACE{vcm=1.2}
Vu u 0 dc 0 ac 1
Ein vsrc vref u 0 1
Rsrc vsrc pad CACE{rsrc=50}
* ---- load per output (gates of the next stage, routing), on top of the buffer's built-in CLP / CLN
Cp outp 0 CACE{cload=0.5e-12}
Cn outn 0 CACE{cload=0.5e-12}
* ---- the IO ring ground, for the iovss rejection
Vgio gio 0 dc 0 ac 0




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1
.control
save v(outp) v(outn)
ac dec 20 10 100meg
let vd = v(outp) - v(outn)
let A = mag(vd)
meas ac a1k find A at=1k
meas ac a100k find A at=100k
let a3 = a1k/sqrt(2)
let f3dB = 1e12
meas ac f3dB when A=a3 fall=1
let Acl_dB = 20*log10(a1k)
set s_a1k = $&a1k
set s_a100k = $&a100k
set s_f3 = $&f3dB
set s_acl = $&Acl_dB
alter @Vu[acmag] = 0
alter @Vio[acmag] = 1
ac dec 20 10 100meg
let vd = v(outp) - v(outn)
let vc = (v(outp) + v(outn))/2
let A = mag(vd)
let C = mag(vc)
meas ac p1k find A at=1k
meas ac p100k find A at=100k
meas ac c1k find C at=1k
set s_pp1k = $&p1k
set s_pp100k = $&p100k
set s_cvdd = $&c1k
alter @Vio[acmag] = 0
alter @Vgio[acmag] = 1
ac dec 20 10 100meg
let vd = v(outp) - v(outn)
let A = mag(vd)
meas ac n1k find A at=1k
meas ac n100k find A at=100k
set s_pn1k = $&n1k
set s_pn100k = $&n100k
alter @Vgio[acmag] = 0
alter @Vref[acmag] = 1
ac dec 20 10 100meg
let vd = v(outp) - v(outn)
let A = mag(vd)
meas ac m1k find A at=1k
let Acl_dB = $s_acl
let f3dB = $s_f3
let PSRRp_1k = 20*log10($s_a1k/$s_pp1k)
let PSRRp_100k = 20*log10($s_a100k/$s_pp100k)
let PSRRn_1k = 20*log10($s_a1k/$s_pn1k)
let PSRRn_100k = 20*log10($s_a100k/$s_pn100k)
let CMRR_1k = 20*log10($s_a1k/m1k)
let CMvdd_1k = 20*log10($s_cvdd)
echo $&Acl_dB $&f3dB $&PSRRp_1k $&PSRRp_100k $&PSRRn_1k $&PSRRn_100k $&CMRR_1k $&CMvdd_1k > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
