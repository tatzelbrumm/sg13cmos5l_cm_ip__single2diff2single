** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_ac.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_ac
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



Vio iovdd 0 dc CACE{vdd} ac 0
Ven en 0 CACE{en=1.2}
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
Vcore vcore 0 CACE{vddl=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
* harness iDAC: sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
Vref vref 0 CACE{vref=1.65}
Vcm vcm 0 CACE{vcm=1.65}
* input: source with series resistance rsrc into the pad
Vin vsrc 0 dc CACE{vref=1.65} ac 1
Rsrc vsrc pad CACE{rsrc=50}
* differential load (internal next stage)
Cp outp 0 CACE{cload=1e-12}
Cn outn 0 CACE{cload=1e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.option warn=1
.control
save v(outp) v(outn)
ac dec 50 1 1G
let vdo = v(outp) - v(outn)
let ad = db(vdo)
meas ac Ad find ad at=1k
let adn = ad - Ad
* default: beyond the sweep (1 GHz)
let f3db = 1e9
meas ac f3db when adn=-3 fall=1
set s_ad = $&Ad
set s_f = $&f3db
alter @vin[acmag]=0
alter @vio[acmag]=1
ac dec 50 1 1G
let vdo2 = v(outp) - v(outn)
let ps = -db(vdo2)
meas ac PSRR_1k find ps at=1k
meas ac PSRR_100k find ps at=100k
let Ad_dB = $s_ad
let f3dB = $s_f
echo $&Ad_dB $&f3dB $&PSRR_1k $&PSRR_100k > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
