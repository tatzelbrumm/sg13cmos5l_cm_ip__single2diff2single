** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/verification/cace/templates/s2d_mpdda_biased_tb_tran.sch
* macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch:
* SPDX-FileCopyrightText: 2026 Christoph Maier SPDX-License-Identifier: Apache-2.0
**.subckt s2d_mpdda_biased_tb_tran
Vdd vdd GND dc CACE{vdd}
Vref vref GND dc CACE{vref=1.2}
Vcm vcm GND dc CACE{vcm=1.2}
CLp voutp GND CACE{cload=0.5p} m=1
CLn voutn GND CACE{cload=0.5p} m=1
Vu u GND pulse(CACE[-CACE{vstep=0.5}/2] CACE[CACE{vstep=0.5}/2] 1u 1n 1n 4u 10u)
Ein pad vref u GND 1
Rpad pad vin 586.9 m=1
x1 vdd GND vin vref vcm voutp voutn voutp voutn vbp vbn vbpc vbnc s2d_mpdda_biased
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(voutp) v(voutn) v(vcm)
tran 1n 5u
let vd = v(voutp) - v(voutn)
let vc = (v(voutp) + v(voutn))/2 - v(vcm)
meas tran vlo find vd at=0.99u
meas tran vhi find vd at=4.9u
let v10 = vlo + 0.1*(vhi - vlo)
let v90 = vlo + 0.9*(vhi - vlo)
meas tran t10 when vd=v10 rise=1
meas tran t90 when vd=v90 rise=1
let t_rise = t90 - t10
let band = 0.01*abs(vhi - vlo)
let dev = abs(vd - vhi)
meas tran tlast when dev=band cross=last
let t_settle = tlast - 1.0005u
meas tran vdmax max vd from=1u to=4.9u
let Overshoot = 100*(vdmax - vhi)/(vhi - vlo)
let avc = abs(vc)
meas tran Vcm_dev max avc from=1u to=4.9u
echo $&t_rise $&t_settle $&Overshoot $&Vcm_dev > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  s2d_mpdda_biased.sym # of pins=13
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sch
.subckt s2d_mpdda_biased vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
xs vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc s2d_mpdda
xb vdd vss vbp vbn vbpc vbnc s2d_bias_lp
.ends


* expanding   symbol:  s2d_mpdda.sym # of pins=13
** sym_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sym
** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch
.subckt s2d_mpdda vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XA1 x y vin vref vdd vss vbp unit_r2
XA2 x y vin vref vdd vss vbp unit_r2
XF1 x y vcm vfbp vdd vss vbp unit_r2
XF2 x y vfbn vcm vdd vss vbp unit_r2
XLP lp vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLPC voutp vbpc lp vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCX voutp vbnc x vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSX x vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XLN ln vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLNC voutn vbpc ln vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCY voutn vbnc y vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSY y vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XCLP vss voutp vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XCLN vss voutn vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XM1 xc yc vfbp vcm vdd vss vbp unit_r2
XM2 xc yc vfbn vcm vdd vss vbp unit_r2
XD dd vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XDC vcmfb vbpc dd vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCXC vcmfb vbnc xc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSXC xc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XCYC vdd vbnc yc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSYC yc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XMDL[3] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[2] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[1] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[0] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  s2d_bias_lp.sym # of pins=6
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sch
.subckt s2d_bias_lp vdd vss vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XBP vbp vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
IBP vbp vss 5u
XBPC vbpc vbpc vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
IBPC vbpc vss 2u
IBN vdd vbn 5u
XBN vbn vbn vss vss sg13_hv_nmos w=6u l=6u ng=1 m=1 mm_ok=1
IBNC vdd vbnc 2u
XBNC vbnc vbnc vss vss sg13_hv_nmos w=1u l=8u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  unit_r2.sym # of pins=7
** sym_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sym
** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sch
.subckt unit_r2 x y gp gn vdd vss vbp
*.opin x
*.opin y
*.ipin gp
*.ipin gn
*.iopin vdd
*.iopin vss
*.ipin vbp
XTa sa vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XTb sb vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XMa y gp sa sa sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XMb x gn sb sb sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XR sa sb vss rhigh w=0.5u l=50.6u m=1 b=0 mm_ok=1
.ends

.GLOBAL GND
.end
