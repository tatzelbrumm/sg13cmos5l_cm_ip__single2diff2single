** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/verification/cace/templates/s2d_mpdda_biased_tb_loop.sch
* macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch:
* SPDX-FileCopyrightText: 2026 Christoph Maier SPDX-License-Identifier: Apache-2.0
**.subckt s2d_mpdda_biased_tb_loop
Vdd vdd GND dc CACE{vdd}
Vref vref GND dc CACE{vref=1.2}
Vcm vcm GND dc CACE{vcm=1.2}
CLp voutp GND CACE{cload=0.5p} m=1
CLn voutn GND CACE{cload=0.5p} m=1
x1 vdd GND vref vref vcm voutp voutn fbp fbn vbp vbn vbpc vbnc s2d_mpdda_biased
Lbp voutp fbp 1G m=1
Lbn voutn fbn 1G m=1
Cbp fbp injp 1 m=1
Cbn fbn injn 1 m=1
Vinjp injp GND dc 0 ac 1
Vinjn injn GND dc 0 ac 1 180
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(voutp) v(voutn) v(fbp) v(fbn)
ac dec 50 10 1G
let T = -(v(voutp) - v(voutn))/(v(fbp) - v(fbn))
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac t0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
set s_T0dm = $&t0
set s_fcdm = $&fc
set s_PMdm = $&phc
set s_GMdm = $&gmdb
alter @Vinjn[acphase] = 0
ac dec 50 10 1G
let T = -(v(voutp) + v(voutn))/(v(fbp) + v(fbn))
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac t0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
let T0dm = $s_T0dm
let fcdm = $s_fcdm
let PMdm = 180 + $s_PMdm
let GMdm = 0 - $s_GMdm
let T0cm = t0
let fccm = fc
let PMcm = 180 + phc
let GMcm = 0 - gmdb
echo $&T0dm $&fcdm $&PMdm $&GMdm $&T0cm $&fccm $&PMcm $&GMcm > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  s2d_mpdda_biased.sym # of pins=13
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sch
.subckt s2d_mpdda_biased vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
xs vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc s2d_mpdda
xb vdd vss vbp vbn vbpc vbnc s2d_bias_lp
.ends


* expanding   symbol:  s2d_mpdda.sym # of pins=13
** sym_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sym
** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch
.subckt s2d_mpdda vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XA1 x y vin vref vdd vss vbp unit_r2
XA2 x y vin vref vdd vss vbp unit_r2
XF1 x y vcm vfbp vdd vss vbp unit_r2
XF2 x y vfbn vcm vdd vss vbp unit_r2
XLP lp vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLPC voutp vbpc lp vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCX voutp vbnc x vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSX x vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XLN ln vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLNC voutn vbpc ln vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCY voutn vbnc y vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSY y vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XCLP vss voutp vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XCLN vss voutn vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XM1 xc yc vfbp vcm vdd vss vbp unit_r2
XM2 xc yc vfbn vcm vdd vss vbp unit_r2
XD dd vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XDC vcmfb vbpc dd vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCXC vcmfb vbnc xc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSXC xc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XCYC vdd vbnc yc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSYC yc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XMDL[3] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[2] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[1] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[0] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  s2d_bias_lp.sym # of pins=6
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sch
.subckt s2d_bias_lp vdd vss vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XBP vbp vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
IBP vbp vss 5u
XBPC vbpc vbpc vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
IBPC vbpc vss 2u
IBN vdd vbn 5u
XBN vbn vbn vss vss sg13_hv_nmos w=6u l=6u ng=1 m=1 mm_ok=1
IBNC vdd vbnc 2u
XBNC vbnc vbnc vss vss sg13_hv_nmos w=1u l=8u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  unit_r2.sym # of pins=7
** sym_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sym
** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sch
.subckt unit_r2 x y gp gn vdd vss vbp
*.opin x
*.opin y
*.ipin gp
*.ipin gn
*.iopin vdd
*.iopin vss
*.ipin vbp
XTa sa vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XTb sb vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XMa y gp sa sa sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XMb x gn sb sb sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XR sa sb vss rhigh w=0.5u l=50.6u m=1 b=0 mm_ok=1
.ends

.GLOBAL GND
.end
