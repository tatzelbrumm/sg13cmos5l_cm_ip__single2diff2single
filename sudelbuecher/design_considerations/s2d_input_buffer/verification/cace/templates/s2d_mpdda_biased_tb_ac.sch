** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/verification/cace/templates/s2d_mpdda_biased_tb_ac.sch
* macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch:
* SPDX-FileCopyrightText: 2026 Christoph Maier SPDX-License-Identifier: Apache-2.0
**.subckt s2d_mpdda_biased_tb_ac
Vdd vdd GND dc CACE{vdd} ac 0
Vref vref GND dc CACE{vref=1.2} ac 0
Vcm vcm GND dc CACE{vcm=1.2} ac 0
CLp voutp vsx CACE{cload=0.5p} m=1
CLn voutn vsx CACE{cload=0.5p} m=1
Vu u GND dc 0 ac 1
Ein vin vref u GND 1
Vss vsx GND dc 0 ac 0
x1 vdd vsx vin vref vcm voutp voutn voutp voutn vbp vbn vbpc vbnc s2d_mpdda_biased
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(voutp) v(voutn)
alter @Vdd[acmag] = 0
alter @Vref[acmag] = 0
ac dec 20 10 100meg
let vd = v(voutp) - v(voutn)
let A = mag(vd)
meas ac a1k find A at=1k
meas ac a100k find A at=100k
let a3 = a1k/sqrt(2)
let f3dB = 1e12
meas ac f3dB when A=a3 fall=1
let Acl_dB = 20*log10(a1k)
set s_a1k = $&a1k
set s_a100k = $&a100k
set s_f3 = $&f3dB
set s_acl = $&Acl_dB
alter @Vu[acmag] = 0
alter @Vdd[acmag] = 1
ac dec 20 10 100meg
let vd = v(voutp) - v(voutn)
let vc = (v(voutp) + v(voutn))/2
let A = mag(vd)
let C = mag(vc)
meas ac p1k find A at=1k
meas ac p100k find A at=100k
meas ac c1k find C at=1k
set s_pp1k = $&p1k
set s_pp100k = $&p100k
set s_cvdd = $&c1k
alter @Vdd[acmag] = 0
alter @Vss[acmag] = 1
ac dec 20 10 100meg
let vd = v(voutp) - v(voutn)
let A = mag(vd)
meas ac n1k find A at=1k
meas ac n100k find A at=100k
set s_pn1k = $&n1k
set s_pn100k = $&n100k
alter @Vss[acmag] = 0
alter @Vref[acmag] = 1
ac dec 20 10 100meg
let vd = v(voutp) - v(voutn)
let A = mag(vd)
meas ac m1k find A at=1k
let Acl_dB = $s_acl
let f3dB = $s_f3
let PSRRp_1k = 20*log10($s_a1k/$s_pp1k)
let PSRRp_100k = 20*log10($s_a100k/$s_pp100k)
let PSRRn_1k = 20*log10($s_a1k/$s_pn1k)
let PSRRn_100k = 20*log10($s_a100k/$s_pn100k)
let CMRR_1k = 20*log10($s_a1k/m1k)
let CMvdd_1k = 20*log10($s_cvdd)
echo $&Acl_dB $&f3dB $&PSRRp_1k $&PSRRp_100k $&PSRRn_1k $&PSRRn_100k $&CMRR_1k $&CMvdd_1k > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  s2d_mpdda_biased.sym # of pins=13
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_mpdda_biased.sch
.subckt s2d_mpdda_biased vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
xs vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc s2d_mpdda
xb vdd vss vbp vbn vbpc vbnc s2d_bias_lp
.ends


* expanding   symbol:  s2d_mpdda.sym # of pins=13
** sym_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sym
** sch_path: macros/sg13cmos5l_IOPadSingle2Diff/schematic/xschem/s2d_mpdda.sch
.subckt s2d_mpdda vdd vss vin vref vcm voutp voutn vfbp vfbn vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.ipin vin
*.ipin vref
*.ipin vcm
*.opin voutp
*.opin voutn
*.ipin vfbp
*.ipin vfbn
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XA1 x y vin vref vdd vss vbp unit_r2
XA2 x y vin vref vdd vss vbp unit_r2
XF1 x y vcm vfbp vdd vss vbp unit_r2
XF2 x y vfbn vcm vdd vss vbp unit_r2
XLP lp vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLPC voutp vbpc lp vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCX voutp vbnc x vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSX x vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XLN ln vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XLNC voutn vbpc ln vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCY voutn vbnc y vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSY y vbn vss vss sg13_hv_nmos w=36u l=6u ng=6 m=1 mm_ok=1
XCLP vss voutp vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XCLN vss voutn vss vss sg13_hv_nmos w=12u l=12u ng=1 m=1 mm_ok=1
XM1 xc yc vfbp vcm vdd vss vbp unit_r2
XM2 xc yc vfbn vcm vdd vss vbp unit_r2
XD dd vcmfb vdd vdd sg13_hv_pmos w=24u l=4u ng=4 m=1 mm_ok=1
XDC vcmfb vbpc dd vdd sg13_hv_pmos w=30u l=3u ng=2 m=1 mm_ok=1
XCXC vcmfb vbnc xc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSXC xc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XCYC vdd vbnc yc vss sg13_hv_nmos w=30u l=3u ng=2 m=1 mm_ok=1
XSYC yc vbn vss vss sg13_hv_nmos w=24u l=6u ng=4 m=1 mm_ok=1
XMDL[3] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[2] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[1] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
XMDL[0] vdd vcmfb vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  s2d_bias_lp.sym # of pins=6
** sym_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sym
** sch_path: sudelbuecher/design_considerations/s2d_input_buffer/xschem/s2d_bias_lp.sch
.subckt s2d_bias_lp vdd vss vbp vbn vbpc vbnc
*.iopin vdd
*.iopin vss
*.iopin vbp
*.iopin vbn
*.iopin vbpc
*.iopin vbnc
XBP vbp vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
IBP vbp vss 5u
XBPC vbpc vbpc vdd vdd sg13_hv_pmos w=1u l=4u ng=1 m=1 mm_ok=1
IBPC vbpc vss 2u
IBN vdd vbn 5u
XBN vbn vbn vss vss sg13_hv_nmos w=6u l=6u ng=1 m=1 mm_ok=1
IBNC vdd vbnc 2u
XBNC vbnc vbnc vss vss sg13_hv_nmos w=1u l=8u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  unit_r2.sym # of pins=7
** sym_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sym
** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/improvements/xschem/unit_r2.sch
.subckt unit_r2 x y gp gn vdd vss vbp
*.opin x
*.opin y
*.ipin gp
*.ipin gn
*.iopin vdd
*.iopin vss
*.ipin vbp
XTa sa vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XTb sb vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1 m=1 mm_ok=1
XMa y gp sa sa sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XMb x gn sb sb sg13_hv_pmos w=20u l=1u ng=2 m=1 mm_ok=1
XR sa sb vss rhigh w=0.5u l=50.6u m=1 b=0 mm_ok=1
.ends

.GLOBAL GND
.end
