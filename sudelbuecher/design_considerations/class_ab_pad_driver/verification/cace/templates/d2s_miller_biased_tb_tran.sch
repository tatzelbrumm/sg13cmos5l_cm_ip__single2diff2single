** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_tran.sch
**.subckt d2s_miller_biased_tb_tran
Vdd vdd GND CACE{vdd}
Vref vref GND CACE{vref=1.65}
Vic vic GND CACE{vicm=1.65}
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
Vd dp GND pulse(-CACE{vstep=0.5} CACE{vstep=0.5} 1u 1n 1n 4u 8u)
Ep vinp vic dp GND 0.5
En vinn vic dp GND -0.5
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(vout)
tran CACE{tstep=2n} 9u
meas tran v0 find v(vout) at=0.99u
meas tran v1 find v(vout) at=4.9u
let dv = v1 - v0
* normalized output: 0 before the rising step, 1 after it
let vn = (v(vout) - v0) / dv
meas tran t10r when vn=0.1 rise=1 from=1u to=5u
meas tran t90r when vn=0.9 rise=1 from=1u to=5u
meas tran t90f when vn=0.9 fall=1 from=5u to=9u
meas tran t10f when vn=0.1 fall=1 from=5u to=9u
let SR_rise = 0.8*dv / (t90r - t10r)
let SR_fall = 0.8*dv / (t10f - t90f)
meas tran vnmax max vn from=1u to=5u
let Overshoot = vnmax - 1
* settling: last time the error leaves the +-1 % band
let er = abs(vn - 1)
let ef = abs(vn)
let tsr = 1u
let tsf = 5u
meas tran tsr when er=0.01 cross=last from=1u to=5u
meas tran tsf when ef=0.01 cross=last from=5u to=9u
let ts_rise = tsr - 1u
let ts_fall = tsf - 5.001u
echo $&SR_rise $&SR_fall $&Overshoot $&ts_rise $&ts_fall > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
