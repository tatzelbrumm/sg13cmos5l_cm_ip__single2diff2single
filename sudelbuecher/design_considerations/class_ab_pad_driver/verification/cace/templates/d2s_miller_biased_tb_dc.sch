** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_dc.sch
**.subckt d2s_miller_biased_tb_dc
Vdd vdd GND CACE{vdd}
Vref vref GND CACE{vref=1.65}
Vic vic GND CACE{vicm=1.65}
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
Vd dp GND dc 0
Ep vinp vic dp GND 0.5
En vinn vic dp GND -0.5
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(vout) v(vref) v(dp) i(vdd) @n.x1.xd.xop.nsg13_hv_pmos[ids] @n.x1.xd.xon.nsg13_hv_nmos[ids]
dc Vd -CACE{vdmax=1} CACE{vdmax=1} CACE{vdstep=0.01}
let vo = v(vout) - v(vref)
meas dc vo0 find vo at=0
meas dc vop find vo at=CACE{vdlin=0.2}
meas dc vom find vo at=-CACE{vdlin=0.2}
* small-signal gain and output offset (vout - vref at vd = 0)
let Gain = (vop - vom) / (2*CACE{vdlin=0.2})
let Vos_out = vo0
* integral nonlinearity: max deviation from the small-signal line over +-vdmax
let dev = abs(vo - vo0 - Gain*v(dp))
meas dc INL max dev
let idd = -i(vdd)
meas dc Idd find idd at=0
* output devices: quiescent currents, and the smaller of the two at full scale
let ip = abs(@n.x1.xd.xop.nsg13_hv_pmos[ids])
let inn = abs(@n.x1.xd.xon.nsg13_hv_nmos[ids])
meas dc IqP find ip at=0
meas dc IqN find inn at=0
let imn = 0.5*(ip + inn - abs(ip - inn))
meas dc ImA find imn at=-CACE{vdmax=1}
meas dc ImB find imn at=CACE{vdmax=1}
let Imin = 0.5*(ImA + ImB - abs(ImA - ImB))
echo $&Gain $&Vos_out $&INL $&Idd $&IqP $&IqN $&Imin > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
