** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_loop.sch
**.subckt d2s_miller_biased_tb_loop
Vdd vdd GND CACE{vdd}
Vref vref GND CACE{vref=1.65}
Vic vic GND CACE{vicm=1.65}
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vic vic vref vout fb vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
Lb vout fb 1G m=1
Cb fb inj 1 m=1
Vinj inj GND dc 0 ac 1
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(vout) v(fb)
ac dec 50 1 1G
let T = -v(vout)/v(fb)
let Tdb = vdb(T)
let Tph = cph(T)*180/pi
meas ac T0 find Tdb at=10
let fc = 0
meas ac fc when Tdb=0 fall=1
let phc = -180
meas ac phc find Tph when Tdb=0 fall=1
let PM = 180 + phc
* gain margin; stays at 1000 dB if the phase never reaches -180 deg
let gmdb = -1000
meas ac gmdb find Tdb when Tph=-180 cross=1
let GM = -gmdb
echo $&T0 $&fc $&PM $&GM > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
