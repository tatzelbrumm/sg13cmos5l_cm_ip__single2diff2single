** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_ac.sch
**.subckt d2s_miller_biased_tb_ac
Vdd vdd GND dc CACE{vdd} ac 0
Vref vref GND CACE{vref=1.65}
Vic vic GND dc CACE{vicm=1.65} ac 0
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
Vd dp GND dc 0 ac 1
Ep vinp vic dp GND 0.5
En vinn vic dp GND -0.5
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
Itest GND vout dc 0 ac 0
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(vout)
* 1) differential signal: Vd ac 1
ac dec 50 1 1G
let adb = vdb(vout)
meas ac Acl find adb at=1k
let adn = adb - Acl
let f3db = 0
meas ac f3db when adn=-3 fall=1
set s_acl = $&Acl
set s_f3db = $&f3db
* 2) supply: vdd ac 1; PSRR referred to the output, -20 log |vout/vdd|
alter @vd[acmag]=0
alter @vdd[acmag]=1
ac dec 50 1 1G
let psr = -vdb(vout)
meas ac PSRR_1k find psr at=1k
meas ac PSRR_100k find psr at=100k
set s_p1 = $&PSRR_1k
set s_p2 = $&PSRR_100k
* 3) input common mode: vic ac 1; CMRR = A_dm / A_cm
alter @vdd[acmag]=0
alter @vic[acmag]=1
ac dec 50 1 1G
let cmdb = vdb(vout)
meas ac Acm find cmdb at=1k
set s_acm = $&Acm
* 4) closed-loop output impedance: 1 A ac into vout
alter @vic[acmag]=0
alter @itest[acmag]=1
ac dec 50 1 1G
let zo = mag(v(vout))
meas ac Zout_1k find zo at=1k
meas ac Zout_1M find zo at=1meg
let Acl_dB = $s_acl
let f3dB = $s_f3db
let PSRR_1k = $s_p1
let PSRR_100k = $s_p2
let CMRR_1k = $s_acl - $s_acm
echo $&Acl_dB $&f3dB $&PSRR_1k $&PSRR_100k $&CMRR_1k $&Zout_1k $&Zout_1M > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
