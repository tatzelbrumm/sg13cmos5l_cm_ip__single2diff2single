** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_noise.sch
**.subckt d2s_miller_biased_tb_noise
Vdd vdd GND CACE{vdd}
Vref vref GND CACE{vref=1.65}
Vic vic GND CACE{vicm=1.65}
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
Vd dp GND dc 0 ac 1
Ep vinp vic dp GND 0.5
En vinn vic dp GND -0.5
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents sparse method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
* .noise does not run with KLU (see the OgueyAebischerBias noise template), hence sparse
.control
* each sweep starts at its spot frequency, so index 0 is the spot value
noise v(vout) vd dec 10 1k 10k
setplot noise1
let en_1k = onoise_spectrum[0]
set s_n1 = $&en_1k
noise v(vout) vd dec 10 100k 1meg
setplot noise3
let en_100k = onoise_spectrum[0]
set s_n2 = $&en_100k
noise v(vout) vd dec 20 CACE{fn_lo=10} CACE{fn_hi=10meg}
setplot noise6
let Vn_int = onoise_total
let En_1k = $s_n1
let En_100k = $s_n2
echo $&En_1k $&En_100k $&Vn_int > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
