** sch_path: sudelbuecher/design_considerations/class_ab_pad_driver/verification/cace/templates/d2s_miller_biased_tb_drive.sch
**.subckt d2s_miller_biased_tb_drive
Vdd vdd GND CACE{vdd}
Vref vref GND CACE{vref=1.65}
Vic vic GND CACE{vicm=1.65}
Vterm vterm GND CACE{vterm=1.65}
x1 vdd GND vinp vinn vref vout vout vbp vbn vbpc vbnc vabp vabn d2s_miller_biased
IQvbp vbp GND CACE[CACE{ibias_err=0}*2e-05]
RQvbp vbp GND CACE[CACE{va_bias=1e12}/2e-05] m=1
IQvbn vdd vbn CACE[CACE{ibias_err=0}*5e-05]
RQvbn vdd vbn CACE[CACE{va_bias=1e12}/5e-05] m=1
IQvbpc vbpc GND CACE[CACE{ibias_err=0}*5e-06]
RQvbpc vbpc GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvbnc vdd vbnc CACE[CACE{ibias_err=0}*5e-06]
RQvbnc vdd vbnc CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabp vabp GND CACE[CACE{ibias_err=0}*5e-06]
RQvabp vabp GND CACE[CACE{va_bias=1e12}/5e-06] m=1
IQvabn vdd vabn CACE[CACE{ibias_err=0}*5e-06]
RQvabn vdd vabn CACE[CACE{va_bias=1e12}/5e-06] m=1
Vd dp GND dc 0
Ep vinp vic dp GND 0.5
En vinn vic dp GND -0.5
RL vout vterm CACE{rload=1k} m=1
CL vout GND CACE{cload=100p} m=1
Rf vout vf 1e12 m=1
Vforce vf GND CACE{vforce=1.65}
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c=typ}



.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(vout) i(vforce)
* 1) swing: Rf open, vd = +-vdbig
dc Vd -CACE{vdbig=3} CACE{vdbig=3} CACE[2*CACE{vdbig=3}]
meas dc Vout_max find v(vout) at=CACE{vdbig=3}
meas dc Vout_min find v(vout) at=-CACE{vdbig=3}
set s_vmax = $&Vout_max
set s_vmin = $&Vout_min
* 2) short circuit: Rf = 1 mohm to vforce
alter @rf[resistance]=1m
dc Vd -CACE{vdbig=3} CACE{vdbig=3} CACE[2*CACE{vdbig=3}]
let isc = i(vforce)
meas dc Isc_src find isc at=CACE{vdbig=3}
meas dc isnk find isc at=-CACE{vdbig=3}
let Isc_snk = -isnk
let Vout_max = $s_vmax
let Vout_min = $s_vmin
echo $&Vout_max $&Vout_min $&Isc_src $&Isc_snk > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
