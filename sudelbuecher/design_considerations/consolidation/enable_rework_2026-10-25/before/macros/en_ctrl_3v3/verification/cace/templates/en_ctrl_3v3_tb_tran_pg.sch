** sch_path: sudelbuecher/design_considerations/consolidation/enable_rework_2026-10-25/before/macros/en_ctrl_3v3/verification/cace/templates/en_ctrl_3v3_tb_tran_pg.sch
**.subckt en_ctrl_3v3_tb_tran_pg
x1 vddh vddl GND en_1v2 sel0_1v2 sel1_1v2 vdd1v2_sense vdd3v3_sense en_3v3 sel0_3v3 sel1_3v3
+ en_ctrl_3v3
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}



.include CACE{DUT_path}
.temp CACE{temp}
.options gmin=1e-12 abstol=1e-12 reltol=1e-4
.option warn=1
* sup: 0 = (vddl, vddh) = (1.08, 3.0) V, 1 = (1.32, 3.6) V, 0.5 = nominal (1.2, 3.3) V
.param s=CACE{sup}
.param vl={1.08+0.24*s} vh={3.0+0.6*s}
Vh vddh 0 {vh}
Cl0 en_3v3 0 CACE{cload}
Cl1 sel0_3v3 0 10f
Cl2 sel1_3v3 0 10f
* supply loss with en_1v2 held high: scenario 1 vdd_1v2 sense, 2 vdd_3v3 sense, 3 vdd_1v2 = vddl and
*+ sense together (slot fallback)
*   ramps to 0 V between 1 us and 2 us
.param c=CACE{scenario}
.param a12='(c==1 || c==3) ? 0 : 1'
.param a33='(c==2) ? 0 : 1'
.param al='(c==3) ? 0 : 1'
Vl vddl 0 PWL(0 {vl} 1u {vl} 2u {al*vl})
Ven en_1v2 0 {vl}
Vs0 sel0_1v2 0 0
Vs1 sel1_1v2 0 0
V12 vdd1v2_sense 0 PWL(0 {vl} 1u {vl} 2u {a12*vl})
V33 vdd3v3_sense 0 PWL(0 {vh} 1u {vh} 2u {a33*vh})
.control
tran 1n 10u
let vmh2 = (CACE{sup} * 0.6 + 3.0) / 2
meas tran t50 when v(en_3v3)=$&vmh2 fall=1
let t_pg = t50 - 1e-6
meas tran Ven_end find v(en_3v3) at=9.9u
echo $&t_pg $&Ven_end > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
