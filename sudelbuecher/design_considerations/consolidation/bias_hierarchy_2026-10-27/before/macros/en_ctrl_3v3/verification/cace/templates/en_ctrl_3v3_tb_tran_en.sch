** sch_path: sudelbuecher/design_considerations/consolidation/bias_hierarchy_2026-10-27/before/macros/en_ctrl_3v3/verification/cace/templates/en_ctrl_3v3_tb_tran_en.sch
**.subckt en_ctrl_3v3_tb_tran_en
x1 vddh vddl GND en_1v2 sel0_1v2 sel1_1v2 vdd1v2_sense vdd3v3_sense en_3v3 sel0_3v3 sel1_3v3
+ en_3v3_b en_ctrl_3v3
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}



.include CACE{DUT_path}
.temp CACE{temp}
.options gmin=1e-12 abstol=1e-12 reltol=1e-4
.option warn=1
* sup: 0 = (vddl, vddh) = (1.08, 3.0) V, 1 = (1.32, 3.6) V, 0.5 = nominal (1.2, 3.3) V
.param s=CACE{sup}
.param vl={1.08+0.24*s} vh={3.0+0.6*s}
Vh vddh 0 {vh}
Cl0 en_3v3 0 CACE{cload}
Cl1 sel0_3v3 0 10f
Cl2 sel1_3v3 0 10f
* enable (rise at 20 ns) and disable (fall at 520 ns) of en_1v2, 100 ps edges; both senses on
Vl vddl 0 {vl}
Ven en_1v2 0 PULSE(0 {vl} 20n 100p 100p 500n 2u)
Vs0 sel0_1v2 0 0
Vs1 sel1_1v2 0 0
V12 vdd1v2_sense 0 {vl}
V33 vdd3v3_sense 0 {vh}
.control
tran 50p 1u
let vmh = CACE{sup} * 0.6 + 3.0
let vmh2 = vmh / 2
let vml2 = (CACE{sup} * 0.24 + 1.08) / 2
meas tran td_on trig v(en_1v2) val=$&vml2 rise=1 targ v(en_3v3) val=$&vmh2 rise=1
meas tran td_off trig v(en_1v2) val=$&vml2 fall=1 targ v(en_3v3) val=$&vmh2 fall=1
echo $&td_on $&td_off > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
