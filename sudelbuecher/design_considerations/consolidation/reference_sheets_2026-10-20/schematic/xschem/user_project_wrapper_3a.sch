v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Pins of user_project_wrapper_3a.v, verbatim -- reference only, nothing
else on this sheet. Read from sg13cmos5l_ocd_chipalooza/verilog/rtl/
user_project_wrapper_3a.v on 2026-09-04 (module lines 38-60). This is
NOT sg13cmos5l_cm_ip__single2diff2single's own boundary -- that macro
uses renamed/reconciled pin names (vin/vout/vcm/...), see
sg13cmos5l_cm_ip__single2diff2single.sch/.sym in this same directory.} 60 -590 0 0 0.3 0.3 {}
C {devices/iopin.sym} 160 -440 2 0 {name=p1 lab=vdd_3v3}
C {devices/iopin.sym} 160 -420 2 0 {name=p2 lab=vdd_1v2}
C {devices/iopin.sym} 160 -400 2 0 {name=p3 lab=vss_3v3}
C {devices/iopin.sym} 160 -380 2 0 {name=p4 lab=vss_1v2}
C {devices/iopin.sym} 160 -360 2 0 {name=p5 lab=vssio}
C {devices/ipin.sym} 160 -320 2 1 {name=p6 lab=enable}
C {devices/ipin.sym} 160 -300 2 1 {name=p7 lab=clk}
C {devices/ipin.sym} 160 -260 2 1 {name=p8 lab=dig_in[23:0]}
C {devices/opin.sym} 160 -240 2 0 {name=p9 lab=dig_out[11:0]}
C {devices/iopin.sym} 160 -200 2 0 {name=p10 lab=analog_pin[2:0]}
C {devices/ipin.sym} 160 -160 2 1 {name=p11 lab=ibias[1:0]}
C {devices/ipin.sym} 160 -140 2 1 {name=p12 lab=vbias}
C {devices/iopin.sym} 160 -100 2 0 {name=p13 lab=analog_bus[3:0]}
C {title.sym} 160 -40 0 0 {name=l1 author="Tim Edwards"}
