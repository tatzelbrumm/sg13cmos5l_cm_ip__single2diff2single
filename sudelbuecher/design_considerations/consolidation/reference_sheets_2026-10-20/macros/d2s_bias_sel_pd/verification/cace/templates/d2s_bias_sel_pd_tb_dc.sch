** sch_path: sudelbuecher/design_considerations/consolidation/reference_sheets_2026-10-20/macros/d2s_bias_sel_pd/verification/cace/templates/d2s_bias_sel_pd_tb_dc.sch
**.subckt d2s_bias_sel_pd_tb_dc
x1 vdd GND vddo vsso ibias vbp vbn vbpc vbnc vabp vabn en_3v3 sel0_3v3 sel1_3v3 d2s_bias_sel_pd
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_typ
.lib cornerPNP.lib CACE{corner_pnp}



.include CACE{DUT_path}
.temp CACE{temp}
.options gmin=1e-15 abstol=1e-15 reltol=1e-4
.option warn=1
.param vd=CACE{vdd}
Vdd vdd 0 {vd}
Vddo vddo 0 {vd}
Vsso vsso 0 0
* harness iDAC model: a PMOS mirror on its own 3.3 V supply sources CACE{iref} into ibias
Vext vext 0 3.3
Iext xg 0 CACE{iref}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* replica loads: each copies one bias diode (same device, gate on the bias line, drain forced to the
*+ gate
* voltage by an ideal buffer), so the current through Vm.. is that diode's current
XRbp dbp vbp vdd vdd sg13_hv_pmos w=5u l=6u ng=1
Ebp ebp 0 vbp 0 1
Vmbp ebp dbp 0
XRbn dbn vbn 0 0 sg13_hv_nmos w=6u l=6u ng=1
Ebn ebn 0 vbn 0 1
Vmbn dbn ebn 0
XRbnc dbnc vbnc 0 0 sg13_hv_nmos w=1u l=8u ng=1
Ebnc ebnc 0 vbnc 0 1
Vmbnc dbnc ebnc 0
XRbpc dbpc vbpc vdd vdd sg13_hv_pmos w=1u l=4u ng=1
Ebpc ebpc 0 vbpc 0 1
Vmbpc ebpc dbpc 0
XRp1 n1r n1r vddo vddo sg13_hv_pmos w=13.32u l=0.6u ng=2
XRp2 dabp vabp n1r vdd sg13_hv_pmos w=6.66u l=0.6u ng=1
Eabp eabp 0 vabp 0 1
Vmabp eabp dabp 0
XRn1 n2r n2r vsso vsso sg13_hv_nmos w=8.8u l=1u ng=2
XRn2 dabn vabn n2r 0 sg13_hv_nmos w=4.4u l=1u ng=1
Eabn eabn 0 vabn 0 1
Vmabn dabn eabn 0
* sel: 0 harness ibias, 1 Oguey-Aebischer core, 2 bandgap core, 3 both cores; en: 1 enabled, 0 disabled
.param sl=CACE{sel} en=CACE{en}
.param s0='(sl==1 || sl==3) ? vd : 0'
.param s1='(sl==2 || sl==3) ? vd : 0'
Ven en_3v3 0 {en*vd}
Vs0 sel0_3v3 0 {s0}
Vs1 sel1_3v3 0 {s1}
.control
op
let Ibp = abs(i(Vmbp))
let Ibn = abs(i(Vmbn))
let Ibnc = abs(i(Vmbnc))
let Ibpc = abs(i(Vmbpc))
let Iabp = abs(i(Vmabp))
let Iabn = abs(i(Vmabn))
* supply currents of the DUT alone (replica loads excluded)
let I_vdd = -i(Vdd) - Ibp - Ibpc
let I_vddo = -i(Vddo) - Iabp
let I_vsso = i(Vsso) - Iabn
let I_ibias = -i(Vext) - CACE{iref}
echo $&Ibp $&Ibn $&Ibnc $&Ibpc $&Iabp $&Iabn $&I_vdd $&I_vddo $&I_vsso $&I_ibias > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
