** sch_path: sudelbuecher/design_considerations/consolidation/reference_sheets_2026-10-20/macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_pd.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_pd
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



Vio iovdd 0 dc CACE{vdd} ac 0
* pdstate 0: en_1v2 low | 1: slot vdd_1v2 off | 2: slot vdd_3v3 off | 3: chip core 1.2 V off (core
*+ ring, vdd_1v2, en_1v2 = 0)
Ven en 0 CACE[1.2*ceil(CACE{pdstate=0}**2/99)*ceil((CACE{pdstate=0} - 3)**2/99)]
Vs12 s12 0 CACE[1.2*ceil((CACE{pdstate=0} - 1)**2/99)*ceil((CACE{pdstate=0} - 3)**2/99)]
Vs33 s33 0 CACE[3.3*ceil((CACE{pdstate=0} - 2)**2/99)]
Vcore vcore 0 CACE[CACE{vddl=1.2}*ceil((CACE{pdstate=0} - 3)**2/99)]
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
* harness iDAC: sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
Vref vref 0 CACE{vref=1.65}
Vcm vcm 0 CACE{vcm=1.65}
* input: source with series resistance rsrc into the pad
Vin vsrc 0 CACE{vpad=1.65}
Rsrc vsrc pad 1m
* differential load (internal next stage)
Cp outp 0 CACE{cload=1e-12}
Cn outn 0 CACE{cload=1e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.option warn=1
.control
save all
op
let Iio_pd = -i(vio)
let Icore_pd = -i(vcore)
let Ipad_pd = -i(vin)
let Ven3 = v(x1.en_3v3)
echo $&Iio_pd $&Icore_pd $&Ipad_pd $&Ven3 > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
