** sch_path: sudelbuecher/design_considerations/consolidation/reference_sheets_2026-10-20/macros/sg13cmos5l_IOPadSingle2Diff/verification/cace/templates/sg13cmos5l_IOPadSingle2Diff_tb_dc.sch
**.subckt sg13cmos5l_IOPadSingle2Diff_tb_dc
x1 iovdd 0 vcore 0 pad outp outn vcm vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadSingle2Diff
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
.include sg13cmos5l_io.spice



Vio iovdd 0 dc CACE{vdd} ac 0
Ven en 0 CACE{en=1.2}
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
Vcore vcore 0 CACE{vddl=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
* harness iDAC: sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
Vref vref 0 CACE{vref=1.65}
Vcm vcm 0 CACE{vcm=1.65}
* input: source with series resistance rsrc into the pad
Vin vsrc 0 dc CACE{vref=1.65} ac 0
Rsrc vsrc pad CACE{rsrc=50}
* differential load (internal next stage)
Cp outp 0 CACE{cload=1e-12}
Cn outn 0 CACE{cload=1e-12}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.option warn=1
.control
save v(pad) v(outp) v(outn) v(vcm) v(vref) i(vio)
dc Vin CACE[CACE{vref=1.65} - 0.5] CACE[CACE{vref=1.65} + 0.5] 0.01
let dp = v(outp) - v(vcm)
let dn = v(outn) - v(vcm)
let vi = v(vsrc) - v(vref)
meas dc dp1 find dp at=CACE[CACE{vref=1.65} + 0.2]
meas dc dp0 find dp at=CACE[CACE{vref=1.65} - 0.2]
meas dc dn1 find dn at=CACE[CACE{vref=1.65} + 0.2]
meas dc dn0 find dn at=CACE[CACE{vref=1.65} - 0.2]
let Gp = (dp1 - dp0) / 0.4
let Gn = (dn1 - dn0) / 0.4
meas dc Vos_p find dp at=CACE{vref=1.65}
meas dc Vos_n find dn at=CACE{vref=1.65}
let cm = 0.5*(v(outp) + v(outn)) - v(vcm)
meas dc Vcm_err find cm at=CACE{vref=1.65}
let iio = -i(vio)
meas dc Iio find iio at=CACE{vref=1.65}
echo $&Gp $&Gn $&Vos_p $&Vos_n $&Vcm_err $&Iio > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
