** sch_path: sudelbuecher/design_considerations/consolidation/reference_sheets_2026-10-20/macros/OgueyAebischerBias/verification/cace/templates/reference_tb_ac_psrr.sch
**.subckt reference_tb_ac_psrr
x1 net2 vbp vbn net1 vbr 0 reference
VDD net2 0 dc CACE{vdd} ac 1
Voff net1 0 0
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.nodeset v(vbp)=200m
.control
save all
ac dec CACE{ac_pts=21} CACE{fstart=1} CACE{fstop=1G}
* v(vbr) is the vdd->vbr transfer (AC amplitude on VDD is exactly 1).
* PSRR_vbr = -20*log10(|v(vbr)|): positive dB = rejection.
let psrr_vbr_db = -db(v(vbr))
meas ac PSRR_vbr find psrr_vbr_db when frequency = CACE{f_psrr=1000}
echo $&PSRR_vbr > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.end
