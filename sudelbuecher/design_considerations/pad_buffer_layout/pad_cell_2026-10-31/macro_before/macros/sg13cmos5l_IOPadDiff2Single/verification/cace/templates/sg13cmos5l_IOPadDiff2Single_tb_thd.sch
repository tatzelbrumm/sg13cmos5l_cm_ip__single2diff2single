** sch_path: sudelbuecher/design_considerations/pad_buffer_layout/pad_cell_2026-10-31/macro_before/macros/sg13cmos5l_IOPadDiff2Single/verification/cace/templates/sg13cmos5l_IOPadDiff2Single_tb_thd.sch
**.subckt sg13cmos5l_IOPadDiff2Single_tb_thd
x1 iovdd 0 vcore 0 pad vinp vinn vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadDiff2Single
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
* IHP IO library (DCNDiode, DCPDiode); on the sourcepath of the PDK .spiceinit
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = ring 3.3 V (front end, bias, output stage), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- differential input around vicm: vinp - vinn = v(dp)
Vref vref 0 CACE{vref=1.65}
Vic vic 0 dc CACE{vicm=1.65} ac 0
Vd dp 0 sin(0 CACE{vdamp=1} CACE{fin=10000})
Ep vinp vic dp 0 0.5
En vinn vic dp 0 -0.5
* ---- load
RL pad vterm CACE{rload=1000}
Vterm vterm 0 CACE{vterm=1.65}
CL pad 0 CACE{cload=1e-10}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-12 gmin=1e-12 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(pad)
tran CACE[4/(1024*CACE{fin=10000})] CACE[6/CACE{fin=10000}] CACE[2/CACE{fin=10000}]
linearize v(pad)
let vv = v(pad)[0,1023]
let ph = 2*pi*CACE{fin=10000}*(time[0,1023] - time[0])
let h1 = 2*sqrt(mean(vv*cos(ph))^2 + mean(vv*sin(ph))^2)
let hs = 0
let k = 2
while k <= 7
  let hk = 2*sqrt(mean(vv*cos(k*ph))^2 + mean(vv*sin(k*ph))^2)
  let hs = hs + hk^2
  let k = k + 1
end
let THD = 20*log10(sqrt(hs)/h1)
let Vout_amp = h1
echo $&THD $&Vout_amp > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
