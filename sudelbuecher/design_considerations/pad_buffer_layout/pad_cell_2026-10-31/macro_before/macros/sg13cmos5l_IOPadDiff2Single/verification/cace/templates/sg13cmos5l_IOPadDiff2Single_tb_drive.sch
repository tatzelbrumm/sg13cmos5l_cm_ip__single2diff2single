** sch_path: sudelbuecher/design_considerations/pad_buffer_layout/pad_cell_2026-10-31/macro_before/macros/sg13cmos5l_IOPadDiff2Single/verification/cace/templates/sg13cmos5l_IOPadDiff2Single_tb_drive.sch
**.subckt sg13cmos5l_IOPadDiff2Single_tb_drive
x1 iovdd 0 vcore 0 pad vinp vinn vref ibias en s0 s1 s12 s33 sg13cmos5l_IOPadDiff2Single
**** begin user architecture code

.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r=typ}
.lib cornerCAP.lib cap_CACE{corner_c=typ}
.lib cornerPNP.lib CACE{corner_pnp=typ}
.lib cornerDIO.lib dio_tt
* IHP IO library (DCNDiode, DCPDiode); on the sourcepath of the PDK .spiceinit
.include sg13cmos5l_io.spice



* ---- supplies: iovdd = ring 3.3 V (front end, bias, output stage), vcore = 1.2 V core ring
Vio iovdd 0 dc CACE{vdd} ac 0
Vcore vcore 0 CACE{vddl=1.2}
* ---- slot-side controls (1.2 V logic) and the slot supplies seen by the presence detectors
Ven en 0 CACE{en=1.2}
Vs0 s0 0 CACE[(CACE{sel=0} % 2)*CACE{vddl=1.2}]
Vs1 s1 0 CACE[floor(CACE{sel=0} / 2)*CACE{vddl=1.2}]
Vs12 s12 0 CACE{vs12=1.2}
Vs33 s33 0 CACE{vs33=3.3}
* ---- harness iDAC: a sourced current from a PMOS mirror on its own 3.3 V supply
Vext vext 0 3.3
Iext xg 0 CACE{ibias=5e-6}
XEd xg xg vext vext sg13_hv_pmos w=5u l=6u
XEm ibias xg vext vext sg13_hv_pmos w=5u l=6u
* ---- differential input around vicm: vinp - vinn = v(dp)
Vref vref 0 CACE{vref=1.65}
Vic vic 0 dc CACE{vicm=1.65} ac 0
Vd dp 0 dc 0 ac 0
Ep vinp vic dp 0 0.5
En vinn vic dp 0 -0.5
* ---- load
RL pad vterm CACE{rload=1000}
Vterm vterm 0 CACE{vterm=1.65}
CL pad 0 CACE{cload=1e-10}
Rf pad vforce 1e12
Vforce vforce 0 CACE{vforce=1.65}




.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
.option warn=1
.control
save v(pad) i(vforce)
dc Vd -CACE{vdbig=3} CACE{vdbig=3} CACE[2*CACE{vdbig=3}]
meas dc Vout_max find v(pad) at=CACE{vdbig=3}
meas dc Vout_min find v(pad) at=-CACE{vdbig=3}
set s_vmax = $&Vout_max
set s_vmin = $&Vout_min
alter @rf[resistance]=1m
dc Vd -CACE{vdbig=3} CACE{vdbig=3} CACE[2*CACE{vdbig=3}]
let isc = i(vforce)
meas dc Isc_src find isc at=CACE{vdbig=3}
meas dc isnk find isc at=-CACE{vdbig=3}
let Isc_snk = -isnk
let Vout_max = $s_vmax
let Vout_min = $s_vmin
echo $&Vout_max $&Vout_min $&Isc_src $&Isc_snk > CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
